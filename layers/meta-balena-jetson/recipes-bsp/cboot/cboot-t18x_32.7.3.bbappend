SRC_URI:remove = "${L4T_URI_BASE}/cboot_src_t18x.tbz2;downloadfilename=cboot_src_t18x-${PV}.tbz2;subdir=${BP}"
SRC_URI:append = "https://developer.nvidia.com/downloads/remack-sdksjetpack-463r32releasev73sourcest186cbootsrct18tbz2;downloadfilename=cboot_src_t18x-${PV}.tbz2;subdir=${BP}"
