SRC_URI:remove = "${L4T_URI_BASE}/public_sources.tbz2;downloadfilename=Jetson-public_sources-${L4T_VERSION}.tbz2"
SRC_URI:append = "https://developer.nvidia.com/downloads/remack-sdksjetpack-463r32releasev73sourcest186publicsourcestbz2;downloadfilename=Jetson-public_sources-${L4T_VERSION}.tbz2"
