TTYS_jetson-nano=" ttyS0"
