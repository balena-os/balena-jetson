FILESEXTRAPATHS:append := "${THISDIR}/${PN}"
