# Flash to internal eMMC - kernel enumerates this, when SD card is in, as mmcblk0
INTERNAL_DEVICE_KERNEL = "mmcblk0"
