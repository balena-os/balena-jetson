TTYS = "ttyTHS0 ttyTCU0 tty0 tty1"
