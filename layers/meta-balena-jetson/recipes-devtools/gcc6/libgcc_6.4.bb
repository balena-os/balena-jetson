require recipes-devtools/gcc6/gcc-${PV}.inc
require libgcc.inc
