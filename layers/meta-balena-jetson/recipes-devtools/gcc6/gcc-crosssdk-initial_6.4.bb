require recipes-devtools/gcc6/gcc-cross-initial_${PV}.bb
require gcc-crosssdk-initial.inc

