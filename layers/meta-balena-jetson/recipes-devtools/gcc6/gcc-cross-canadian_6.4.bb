require recipes-devtools/gcc6/gcc-${PV}.inc
require gcc-cross-canadian.inc



