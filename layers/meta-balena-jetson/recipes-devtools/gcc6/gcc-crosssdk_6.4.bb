require recipes-devtools/gcc6/gcc-cross_${PV}.bb
require gcc-crosssdk.inc
