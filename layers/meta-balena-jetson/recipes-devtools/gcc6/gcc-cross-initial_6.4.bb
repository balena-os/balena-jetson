require recipes-devtools/gcc6/gcc-cross_${PV}.bb
require gcc-cross-initial.inc
