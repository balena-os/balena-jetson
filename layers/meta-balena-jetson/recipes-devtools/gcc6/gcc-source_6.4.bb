require recipes-devtools/gcc6/gcc-${PV}.inc
require recipes-devtools/gcc6/gcc-source.inc

EXCLUDE_FROM_WORLD = "1"
