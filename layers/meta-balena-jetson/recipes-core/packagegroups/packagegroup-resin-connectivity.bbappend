CONNECTIVITY_FIRMWARES_append_jetson-nano = " \
    linux-firmware-iwlwifi-8265 \
    linux-firmware-iwlwifi-9260 \
    linux-firmware-ibt-12-16 \
"

CONNECTIVITY_FIRMWARES_append_jetson-nano-emmc = " \
    linux-firmware-iwlwifi-8265 \
    linux-firmware-iwlwifi-9260 \
    linux-firmware-ibt-12-16 \
"
