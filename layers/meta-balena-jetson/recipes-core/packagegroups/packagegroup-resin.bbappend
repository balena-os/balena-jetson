RDEPENDS:remove:${PN} = "kernel-image-initramfs"
