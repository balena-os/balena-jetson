CONNECTIVITY_FIRMWARES:append:jetson-nano = " \
    linux-firmware-iwlwifi-8265 \
    linux-firmware-iwlwifi-9260 \
"

CONNECTIVITY_FIRMWARES:append:jetson-nano-emmc = " \
    linux-firmware-iwlwifi-8265 \
    linux-firmware-iwlwifi-9260 \
"

CONNECTIVITY_FIRMWARES:append:jetson-tx2 = " \
    linux-firmware-ath10k-qca6174 \
    linux-firmware-ath10k \
"
