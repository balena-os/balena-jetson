IWLWIFI_FW_MIN_API[8265] = "22"
